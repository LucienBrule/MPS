# Keil uVision project HID.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: HID
  c flags: Optim=2 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT6: RAM 0x20020000 size 0x1000
  memory RVCT9: RAM 0x20021000 size 0x5f000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c HID.c USBD_User_HID_0.c
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: HID
  c flags: Optim=4 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0, Compiler:Event Recorder 1.2.1, USB:CORE 6.12.4, USB:CORE 6.12.4, USB:Device 6.12.4, USB:Device:HID 6.12.4, Board Support:Buttons 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:LCD 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:Graphic LCD 1.1.0, Board Support:LED 1.1.0, CMSIS Driver:USB Device:Full-speed 1.10.0, CMSIS Driver:USB Device:High-speed 1.12.0, Device:STM32Cube Framework:Classic 1.2.5, Device:STM32Cube HAL:Common 1.2.4, Device:STM32Cube HAL:Cortex 1.2.4, Device:STM32Cube HAL:DMA 1.2.4, Device:STM32Cube HAL:DMA2D 1.2.4, Device:STM32Cube HAL:DSI 1.2.4, Device:STM32Cube HAL:GPIO 1.2.4, Device:STM32Cube HAL:I2C 1.2.4, Device:STM32Cube HAL:LTDC 1.2.4, Device:STM32Cube HAL:PWR 1.2.4, Device:STM32Cube HAL:RCC 1.2.4, Device:STM32Cube HAL:SDRAM 1.2.4, Device:STM32Cube HAL:SRAM 1.2.4, Device:Startup 1.2.2
